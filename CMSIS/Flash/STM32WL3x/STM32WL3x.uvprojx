# Keil uVision project STM32WL3x.uvprojx, settings and files
target STM32WL3x_256K (6210000::V6.21::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: IRAM(0x20000000,0x00020000) IROM(0x00000000,0x00040000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ESEL ELITTLE
  output: STM32WL3x_256K
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=5 v6LangP=3
  c define: FLASH_MEM, STM32WL3x_256K
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
  group Program Functions
    ./: FlashPrg.c
  group Device Description
    ./: FlashDev.c
target STM32WL3x_128K (6210000::V6.21::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: STM32WL3x_128K
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=5 v6LangP=3
  c define: FLASH_MEM, STM32WL3x_128K
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
target STM32WL3x_64K (6210000::V6.21::ARMCLANG)
  device: ARMCM0P ARM
  pack: ARM.Cortex_DFP.1.1.0
  cpu: as above
  output: STM32WL3x_64K
  AfterMake: cmd.exe /C copy "!L" "..\@L.FLM"
  c flags: Optim=3 v6Lang=5 v6LangP=3
  c define: FLASH_MEM, STM32WL3x_64K
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  scatter file: .\Target.lin
  link misc: --diag_suppress L6305
